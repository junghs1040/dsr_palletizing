Commit message: 2022.07.28

File: boxes_spawner/urdf/box1.urdf (robot description, URDF)
Before this commit: robot box1, 1 links, 0 joints
Links:
- link box1: geometry collision box size=0.5 0.5 0.05; visual box size=0.5 0.5 0.05
